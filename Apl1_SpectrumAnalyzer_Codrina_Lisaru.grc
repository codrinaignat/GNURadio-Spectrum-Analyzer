options:
  parameters:
    author: Codrina Lisaru
    copyright: Codrina Lisaru
    generate_options: qt_gui
    id: Apl1_spectrum_analyzer
    output_language: python
    title: Apl1 Spectrum Analyzer
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    label: Bandwidth in Hz
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: 100e6
    value: '4000'
  states: {}
- name: Center_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Center frequency in Hz
    orient: Qt.Horizontal
    start: 22.93e6
    step: 12.5e3
    stop: 1760e6
    value: 22.93e6
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: RF Gain in dB
    orient: Qt.Vertical
    start: '0'
    step: '1'
    stop: '50'
    value: '22.9'
  states: {}
- name: bits_per_sample
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'tab_widget@1: 0,1,1,1'
    label: Bits per sample - wav
    label0: 8 bits
    label1: 16 bits
    label2: 32 bits
    label3: 64 bits
    num_opts: '4'
    option0: '8'
    option1: '16'
    option2: '32'
    option3: '64'
    type: int
    value: '8'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,3,1,1
    label: Sample rate
    orient: Qt.Horizontal
    start: '1'
    step: 1e3
    stop: 2.4e6
    value: '2000000'
  states: {}
- name: uiselect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'tab_widget@1: 0,0,1,1'
    label: Options
    label0: Don't record data
    label1: Record data
    labels: '["Don''t record data", "Record data"]'
    num_opts: '2'
    option0: '0'
    option1: '1 '
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: uiselect
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 3.2e6
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 3.2e6
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: bits_per_sample
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 1 - Analizor spectral\SavedData.wav
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'tab_widget@0: 1,1,1,1'
    name: Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'tab_widget@1: 2,1,1,1'
    name: Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'tab_widget@0: 0,0,1,1'
    name: Spectrum Analyzer
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'tab_widget@1: 1,0,1,1'
    name: Spectrum Analyzer
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'tab_widget@0: 1,0,1,1'
    name: Time Domain
    size: '1024'
    srate: samp_rate
    type: complex
    yunit: time
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'tab_widget@1: 2,0,1,1'
    name: Time Domain
    size: '1024'
    srate: samp_rate
    type: complex
    yunit: time
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@0: 0,1,1,1'
    name: Waterfall (Spectrogram)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@1: 1,1,1,1'
    name: Waterfall (Spectrogram)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: Center_frequency
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,4
    label0: No data record
    label1: Record data
    num_tabs: '2'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '1', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
